KERNEL_DEVICETREE_clearfog = "armada-388-clearfog.dtb"
KERNEL_DEVICETREE_clearfog-gtr-s4 = "armada-388-clearfog-s4.dtb"
KERNEL_DEVICETREE_clearfog-gtr-l8 = "armada-388-clearfog-l8.dtb"