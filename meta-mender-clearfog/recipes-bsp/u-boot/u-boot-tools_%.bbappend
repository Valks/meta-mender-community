require recipes-bsp/u-boot/u-boot-common.inc