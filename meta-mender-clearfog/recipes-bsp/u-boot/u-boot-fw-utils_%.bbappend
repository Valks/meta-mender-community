require recipes-bsp/u-boot/u-boot-clearfog-mender.inc
